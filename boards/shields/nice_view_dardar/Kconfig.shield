## boards/shields/nice_view_dardar/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_DARDAR
    def_bool $(shields_list_contains,nice_view_dardar)
```
